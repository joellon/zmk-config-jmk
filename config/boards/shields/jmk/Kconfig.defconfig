## config/boards/shields/jmk/Kconfig.defconfig
```kconfig
if SHIELD_JMK

    config ZMK_KEYBOARD_NAME
        default "jmk"
    
    config BT_CTLR
        default BT

endif
```
